// Generated for: spectre
// Generated on: Aug  9 09:08:18 2024
// Design library name: LDO.PROJ
// Design cell name: my_mos_LUTGEN
// Design view name: schematic
simulator lang=spectre
global 0
parameters ADT_WN ADT_LN ADT_FN ADT_MN ADT_WP ADT_LP ADT_FP ADT_MP
include "/home/cadence/gpdk045_v_5_0/gpdk045/../models/spectre/gpdk045.scs" section=mc

// Library name: LDO.PROJ
// Cell name: my_mos_LUTGEN
// View name: schematic
M0 (net1 net3 net4 net2) g45n1hvt w=(ADT_WN) l=ADT_LN nf=ADT_FN as=(((ADT_WN) / (ADT_FN)) < 119.5n) ? ((((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) + (floor(((ADT_FN) - 1) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WN) / (ADT_FN)) * 100n))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) : 0)) / 1 : (((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) + (floor(((ADT_FN) - 1) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WN) / (ADT_FN)))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) : 0)) / 1 \
         ad=(((ADT_WN) / (ADT_FN)) < 119.5n) ? ((floor((ADT_FN) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WN) / (ADT_FN)) * 100n))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) : 0)) / 1 : ((floor((ADT_FN) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WN) / (ADT_FN)))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) : 0)) / 1 \
         ps=(((ADT_WN) / (ADT_FN)) < 119.5n) ? (((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) + (floor(((ADT_FN) - 1) / 2.0) * ((2 * (((60n) - 0) + 60n)) + 440n)) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? ((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) : 0)) / 1 : (((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WN) / (ADT_FN)))) + (floor(((ADT_FN) - 1) / 2.0) * ((2 * (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n))) + (2 * ((ADT_WN) / (ADT_FN))))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? ((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WN) / (ADT_FN)))) : 0)) / 1 \
         pd=(((ADT_WN) / (ADT_FN)) < 119.5n) ? ((floor((ADT_FN) / 2.0) * ((2 * (((60n) - 0) + 60n)) + 440n)) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? ((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) : 0)) / 1 : ((floor((ADT_FN) / 2.0) * ((2 * (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n))) + (2 * ((ADT_WN) / (ADT_FN))))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? ((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WN) / (ADT_FN)))) : 0)) / 1 \
         nrd=(((ADT_WN) / (ADT_FN)) < 119.5n) ? ((floor((ADT_FN) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WN) / (ADT_FN)) * 100n))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) : 0)) / 1 : ((floor((ADT_FN) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WN) / (ADT_FN)))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) != 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) : 0)) / 1 / (((ADT_WN) / (ADT_FN)) * (ADT_FN) * ((ADT_WN) / (ADT_FN)) * (ADT_FN)) \
         nrs=(((ADT_WN) / (ADT_FN)) < 119.5n) ? ((((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) + (floor(((ADT_FN) - 1) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WN) / (ADT_FN)) * 100n))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WN) / (ADT_FN)) * 50n)) : 0)) / 1 : (((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) + (floor(((ADT_FN) - 1) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WN) / (ADT_FN)))) + ((((ADT_FN) / 2) - floor((ADT_FN) / 2) == 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WN) / (ADT_FN))) : 0)) / 1 / (((ADT_WN) / (ADT_FN)) * (ADT_FN) * ((ADT_WN) / (ADT_FN)) * (ADT_FN)) \
         sa=(((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) \
         sb=(((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) \
         sd=(((ADT_WN) / (ADT_FN)) < 119.5n) ? (((60n) - 0) + 60n) + (2*5e-08) : (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) \
         sca=(( ((ADT_WN) / (ADT_FN)) * ( (((1u) * (1u) / ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)) - ((1u) * (1u) / (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN))) + ((1u) * (1u) / ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)) - ((1u) * (1u)/ (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN)))) + ( ADT_LN * ( (((1u) * (1u) / (60n)) - ((1u) * (1u) / ((60n)+((ADT_WN) / (ADT_FN))))) + ((1u) * (1u) / (60n)) - ((1u) * (1u)/ ((60n)+((ADT_WN) / (ADT_FN))))))) / (((ADT_WN) / (ADT_FN)) * ADT_LN) \
         scb=((((ADT_WN) / (ADT_FN)) * ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/10 + (1u)/100)*exp(-10 * ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN)/10 + (1u)/100)*exp(-10 * (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN) / (1u)) + (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/10 + (1u)/100)*exp(-10 * ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN)/10 + (1u)/100)*exp(-10 * (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN) / (1u)))) + (ADT_LN * (((60n)/10 + (1u)/100)*exp(-10 * (60n) / (1u)) - (((60n)+((ADT_WN) / (ADT_FN)))/10 + (1u)/100)*exp(-10 * ((60n)+((ADT_WN) / (ADT_FN))) / (1u)) + ((60n)/10 + (1u)/100)*exp(-10 * (60n) / (1u)) - (((60n)+((ADT_WN) / (ADT_FN)))/10 + (1u)/100)*exp(-10 * ((60n)+((ADT_WN) / (ADT_FN))) / (1u))))) / (((ADT_WN) / (ADT_FN)) * ADT_LN) \
         scc=((((ADT_WN) / (ADT_FN)) * ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/20 + (1u)/400)*exp(-20 * ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN)/20 + (1u)/400)*exp(-20 * (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN) / (1u)) + (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/20 + (1u)/400)*exp(-20 * ((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN)/20 + (1u)/400)*exp(-20 * (((((ADT_WN) / (ADT_FN)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LN) / (1u)))) + (ADT_LN * (((60n)/20 + (1u)/400)*exp(-20 * (60n) / (1u)) - (((60n)+((ADT_WN) / (ADT_FN)))/20 + (1u)/400)*exp(-20 * ((60n)+((ADT_WN) / (ADT_FN))) / (1u)) + ((60n)/20 + (1u)/400)*exp(-20 * (60n) / (1u)) - (((60n)+((ADT_WN) / (ADT_FN)))/20 + (1u)/400)*exp(-20 * ((60n)+((ADT_WN) / (ADT_FN))) / (1u))))) / (((ADT_WN) / (ADT_FN)) * ADT_LN) \
         m=(ADT_MN)
M1 (net05 net07 net08 net06) g45p1hvt w=(ADT_WP) l=ADT_LP nf=ADT_FP as=(((ADT_WP) / (ADT_FP)) < 119.5n) ? ((((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) + (floor(((ADT_FP) - 1) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WP) / (ADT_FP)) * 100n))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) : 0)) / 1 : (((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) + (floor(((ADT_FP) - 1) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WP) / (ADT_FP)))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) : 0)) / 1 \
         ad=(((ADT_WP) / (ADT_FP)) < 119.5n) ? ((floor((ADT_FP) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WP) / (ADT_FP)) * 100n))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) : 0)) / 1 : ((floor((ADT_FP) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WP) / (ADT_FP)))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) : 0)) / 1 \
         ps=(((ADT_WP) / (ADT_FP)) < 119.5n) ? (((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) + (floor(((ADT_FP) - 1) / 2.0) * ((2 * (((60n) - 0) + 60n)) + 440n)) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? ((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) : 0)) / 1 : (((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WP) / (ADT_FP)))) + (floor(((ADT_FP) - 1) / 2.0) * ((2 * (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n))) + (2 * ((ADT_WP) / (ADT_FP))))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? ((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WP) / (ADT_FP)))) : 0)) / 1 \
         pd=(((ADT_WP) / (ADT_FP)) < 119.5n) ? ((floor((ADT_FP) / 2.0) * ((2 * (((60n) - 0) + 60n)) + 440n)) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? ((2 * (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n))) + 340n) : 0)) / 1 : ((floor((ADT_FP) / 2.0) * ((2 * (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n))) + (2 * ((ADT_WP) / (ADT_FP))))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? ((2 * (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))) + (2 * ((ADT_WP) / (ADT_FP)))) : 0)) / 1 \
         nrd=(((ADT_WP) / (ADT_FP)) < 119.5n) ? ((floor((ADT_FP) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WP) / (ADT_FP)) * 100n))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) : 0)) / 1 : ((floor((ADT_FP) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WP) / (ADT_FP)))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) != 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) : 0)) / 1 / (((ADT_WP) / (ADT_FP)) * (ADT_FP) * ((ADT_WP) / (ADT_FP)) * (ADT_FP)) \
         nrs=(((ADT_WP) / (ADT_FP)) < 119.5n) ? ((((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) + (floor(((ADT_FP) - 1) / 2.0) * (((((60n) - 0) + 60n) * 120n) + (((ADT_WP) / (ADT_FP)) * 100n))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? (((50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) * 120n) + (((ADT_WP) / (ADT_FP)) * 50n)) : 0)) / 1 : (((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) + (floor(((ADT_FP) - 1) / 2.0) * ((60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) * ((ADT_WP) / (ADT_FP)))) + ((((ADT_FP) / 2) - floor((ADT_FP) / 2) == 0) ? ((100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) * ((ADT_WP) / (ADT_FP))) : 0)) / 1 / (((ADT_WP) / (ADT_FP)) * (ADT_FP) * ((ADT_WP) / (ADT_FP)) * (ADT_FP)) \
         sa=(((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) \
         sb=(((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n)) \
         sd=(((ADT_WP) / (ADT_FP)) < 119.5n) ? (((60n) - 0) + 60n) + (2*5e-08) : (60n > (((60n) - 0) + 50n) ? 60n : (((60n) - 0) + 50n)) \
         sca=(( ((ADT_WP) / (ADT_FP)) * ( (((1u) * (1u) / ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)) - ((1u) * (1u) / (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP))) + ((1u) * (1u) / ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)) - ((1u) * (1u)/ (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP)))) + ( ADT_LP * ( (((1u) * (1u) / (60n)) - ((1u) * (1u) / ((60n)+((ADT_WP) / (ADT_FP))))) + ((1u) * (1u) / (60n)) - ((1u) * (1u)/ ((60n)+((ADT_WP) / (ADT_FP))))))) / (((ADT_WP) / (ADT_FP)) * ADT_LP) \
         scb=((((ADT_WP) / (ADT_FP)) * ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/10 + (1u)/100)*exp(-10 * ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP)/10 + (1u)/100)*exp(-10 * (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP) / (1u)) + (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/10 + (1u)/100)*exp(-10 * ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP)/10 + (1u)/100)*exp(-10 * (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP) / (1u)))) + (ADT_LP * (((60n)/10 + (1u)/100)*exp(-10 * (60n) / (1u)) - (((60n)+((ADT_WP) / (ADT_FP)))/10 + (1u)/100)*exp(-10 * ((60n)+((ADT_WP) / (ADT_FP))) / (1u)) + ((60n)/10 + (1u)/100)*exp(-10 * (60n) / (1u)) - (((60n)+((ADT_WP) / (ADT_FP)))/10 + (1u)/100)*exp(-10 * ((60n)+((ADT_WP) / (ADT_FP))) / (1u))))) / (((ADT_WP) / (ADT_FP)) * ADT_LP) \
         scc=((((ADT_WP) / (ADT_FP)) * ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/20 + (1u)/400)*exp(-20 * ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP)/20 + (1u)/400)*exp(-20 * (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP) / (1u)) + (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)/20 + (1u)/400)*exp(-20 * ((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n) / (1u)) - ((((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP)/20 + (1u)/400)*exp(-20 * (((((ADT_WP) / (ADT_FP)) < 119.5n) ? (50n > (((60n) - 0) + 60n) ? 50n : (((60n) - 0) + 60n)) + 5e-08 : (100n > (((60n) - 0) + 80n) ? 100n : (((60n) - 0) + 80n))+60n)+ADT_LP) / (1u)))) + (ADT_LP * (((60n)/20 + (1u)/400)*exp(-20 * (60n) / (1u)) - (((60n)+((ADT_WP) / (ADT_FP)))/20 + (1u)/400)*exp(-20 * ((60n)+((ADT_WP) / (ADT_FP))) / (1u)) + ((60n)/20 + (1u)/400)*exp(-20 * (60n) / (1u)) - (((60n)+((ADT_WP) / (ADT_FP)))/20 + (1u)/400)*exp(-20 * ((60n)+((ADT_WP) / (ADT_FP))) / (1u))))) / (((ADT_WP) / (ADT_FP)) * ADT_LP) \
         m=(ADT_MP)
simulatorOptions options reltol=1e-3 vabstol=1e-6 iabstol=1e-12 temp=27 \
    tnom=27 scalem=1.0 scale=1.0 gmin=1e-12 rforce=1 maxnotes=5 maxwarns=5 \
    digits=5 cols=80 pivrel=1e-3 sensfile="../psf/sens.output" \
    checklimitdest=psf
modelParameter info what=models where=rawfile
element info what=inst where=rawfile
outputParameter info what=output where=rawfile
designParamVals info what=parameters where=rawfile
primitives info what=primitives where=rawfile
subckts info what=subckts where=rawfile
saveOptions options save=allpub
